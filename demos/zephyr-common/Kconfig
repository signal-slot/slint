## demos/zephyr-common/boards/native_sim_native_64.conf
```kconfig
# Copyright © SixtyFPS GmbH <info@slint.dev>
# SPDX-License-Identifier: MIT

# マウスをタッチとして Slint に渡す.
CONFIG_INPUT_SDL_TOUCH=y
```
